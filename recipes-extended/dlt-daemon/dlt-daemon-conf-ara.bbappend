
# Silence build warnings on yocto gatesgarth about tailing slash
S = "${WORKDIR}"
