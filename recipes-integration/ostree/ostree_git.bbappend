
# This append file is used to update the version in the original
# ostree recipe from meta-updater upstream layer to 2018.8
# To be used by ucm-package-manager from meta-ara layer

SRC_URI = "gitsm://github.com/ostreedev/ostree.git;tag=v2018.8"
SRCREV = ""
PV = "v2018.8"
